File: HW-MAPLE-Large/V4.0/AddOnZigbeeSMD/V4-AddOnZigbee-SMD-V006.sch (EAGLE design)
At the start: 5 parts

Commit message: V4
Other:
- moved on the sheet: C6, C7, CC-DEBUG, UART0
